File: Subshhets/GPIO Expanders.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Schematic Update-1.1
Connections:
- no-connect marks 4 -> 6
